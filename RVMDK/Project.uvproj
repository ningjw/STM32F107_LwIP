# Keil uVision project Project.uvproj, settings and files
target STM3210C-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c misc: --diag_suppress 236
  c include: ..\User\inc;..\STM32F10x_StdPeriph_Driver\inc;..\STM32_ETH_Driver\inc;..\CMSIS\Core\CM3;..\lwip-1.3.1\port\;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/src/: stm32f10x_it.c main.c stm32f107.c netconf.c
    ../lwip-1.3.1/port/: httpd.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_i2c.c
  group STM32_ETH_Driver
    ../STM32_ETH_Driver/src/: stm32_eth.c
  group LwIP
    ../lwip-1.3.1/port/: ethernetif.c
    ../lwip-1.3.1/src/api/: tcpip.c api_lib.c netbuf.c netifapi.c netdb.c api_msg.c err.c
    ../lwip-1.3.1/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/src/netif/: etharp.c
  group CMSIS
    ../CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group RVMDK
    ../CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
